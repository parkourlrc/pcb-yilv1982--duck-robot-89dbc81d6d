# Repository parkourlrc/pcb-yilv1982--duck-robot-89dbc81d6d (continued)

## KiCad design docs/references/扩展板乙版降本/before-audio-connector-fit.kicad_pcb (continued)

Parts:
C731, C732, C733, C738: 1uF; C_0603_1608Metric; MPN CL10A105KB8NNNC; LCSC C15849
C734, C736: 10uF; C_0603_1608Metric; MPN C1608X5R1A106KT000E; LCSC C76608
C735, C737: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C739, C740: 220pF; C_0603_1608Metric; MPN 0603CG221J500NT; LCSC C156398
FB701: 600R@100MHz; L_0603_1608Metric; MPN BLM18KG601SN1D; LCSC C85833
FB702, FB703: 120R@100MHz; L_0603_1608Metric; MPN PE-0603PFB121ST; LCSC C2661472
J506: SPEAKER; A1251_2P_B; MPN A1251WV-2P; LCSC C5333427
R731: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
U803: PAM8406DR; SOIC-16_3.9x9.9mm_P1.27mm; MPN PAM8406DR; LCSC C86270

Connections:
+5V: C734.1, C735.1, C736.1, C737.1, FB701.1, U803.4 (PVDDL), U803.13 (PVDDR); also elsewhere on the board
AMP_LEFT_INPUT: C731.2, U803.7 (INL)
AMP_RIGHT_INPUT: C732.2, U803.10 (INR)
AMP_R_N_RAW: FB702.1, U803.14 (-OUT_R)
AMP_R_P_RAW: FB703.1, U803.16 (+OUT_R)
AMP_VDD_FILT: C738.1, FB701.2, U803.6 (VDD)
AMP_VREF: C733.1, U803.8 (VREF)
AUDIO_AMP_EN: R731.2, U803.12 (~SHND)
CODEC_LEFT_LOP: C731.1; also elsewhere on the board
CODEC_RIGHT_LOP: C732.1; also elsewhere on the board
SPK_N: C739.1, FB702.2, J506.2
SPK_P: C740.1, FB703.2, J506.1

Notes on the sheet:
B.0 开发候选；脚位已建立，制造/成本和首板验收尚未完成。

Parts:
C721, C725: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C722, C723, C724: 1uF; C_0603_1608Metric; MPN CL10A105KB8NNNC; LCSC C15849
J505: J505_MIC; A1251_2P_B; MPN A1251WV-2P; LCSC C5333427
J507: J507_MIC; A1251_2P_B; MPN A1251WV-2P; LCSC C5333427
MK701: MEMS_MIC; LMA2718_B; MPN LMA2718T421-OA5-2; LCSC C7587901
R721, R722: 2.2k; R_0603_1608Metric; MPN 0603WAF2201T5E; LCSC C4190

Connections:
MICBIAS: C725.1, R721.1, R722.1; also elsewhere on the board
MIC_EXT_L: C723.1, J505.2, R721.2
MIC_EXT_L_AC: C723.2; also elsewhere on the board
MIC_EXT_R: C724.1, J507.2, R722.2
MIC_EXT_R_AC: C724.2; also elsewhere on the board
MIC_ONBOARD_AC: C722.2; also elsewhere on the board
MIC_ONBOARD_OUT: C722.1, MK701.1 (OUT)

Notes on the sheet:
B.0 开发候选；脚位已建立，制造/成本和首板验收尚未完成。
