# Repository parkourlrc/pcb-yilv1982--duck-robot-89dbc81d6d

## KiCad design docs/references/扩展板乙版降本/before-audio-connector-fit.kicad_pcb

Parts:
C701, C704, C705, C707, C709, C711, C713: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C702, C706, C708, C710, C712: 1uF; C_0603_1608Metric; MPN CL10A105KB8NNNC; LCSC C15849
C703: 10uF; C_0603_1608Metric; MPN C1608X5R1A106KT000E; LCSC C76608
R701: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
U701: TLV320AIC3104; TI_RHB0032E_AIC3104_EP345; MPN TLV320AIC3104IRHBR; LCSC C181753
U702: XC6206P182MR; SOT-23; MPN XC6206P182MR; LCSC C347373
Y701: 12MHz; Oscillator_SMD_Abracon_ASDMB-4Pin_2.5x2.0mm; MPN OT3EL89CJI-111YLC-12M; LCSC C7425459

Connections:
AUDIO_MCLK: U701.1 (MCLK), Y701.3 (OUT)
CODEC_LEFT_LOP: U701.27 (LEFT_LOP); also elsewhere on the board
CODEC_RIGHT_LOP: U701.29 (RIGHT_LOP); also elsewhere on the board
CODEC_RST: C701.1, R701.2, U701.31 (~RESET); also elsewhere on the board
I2C5_SCL: U701.8 (SCL); also elsewhere on the board
I2C5_SDA: U701.9 (SDA); also elsewhere on the board
I2S_BCLK: U701.2 (BCLK); also elsewhere on the board
I2S_LRCK: U701.3 (WCLK); also elsewhere on the board
I2S_SDI: U701.5 (DOUT); also elsewhere on the board
I2S_SDO: U701.4 (DIN); also elsewhere on the board
MICBIAS: U701.15 (MICBIAS); also elsewhere on the board
MIC_EXT_L_AC: U701.10 (MIC1LP/LINE1LP); also elsewhere on the board
MIC_EXT_R_AC: U701.12 (MIC1RP/LINE1RP); also elsewhere on the board
MIC_ONBOARD_AC: U701.16 (MIC2R/LINE2R); also elsewhere on the board

Notes on the sheet:
B.0 开发候选；脚位已建立，制造/成本和首板验收尚未完成。
