# Repository parkourlrc/pcb-yilv1982--duck-robot-89dbc81d6d (continued)

## KiCad design docs/references/扩展板乙版降本/before-audio-connector-fit.kicad_pcb (continued)

Parts:
C701, C704, C705, C707, C709, C711, C713: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C702, C706, C708, C710, C712: 1uF; C_0603_1608Metric; MPN CL10A105KB8NNNC; LCSC C15849
C703: 10uF; C_0603_1608Metric; MPN C1608X5R1A106KT000E; LCSC C76608
R701: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
U701: TLV320AIC3104; TI_RHB0032E_AIC3104_EP345; MPN TLV320AIC3104IRHBR; LCSC C181753
U702: XC6206P182MR; UMW_XC6206_SOT23_B; MPN XC6206P182MR; LCSC C347373
Y701: 12MHz; YXC_2520_YSO110TR_B; MPN OT3EL89CJI-111YLC-12M; LCSC C7425459

Connections:
AUDIO_MCLK: U701.1 (MCLK), Y701.3 (OUT)
CODEC_LEFT_LOP: U701.27 (LEFT_LOP); also elsewhere on the board
CODEC_RIGHT_LOP: U701.29 (RIGHT_LOP); also elsewhere on the board
CODEC_RST: C701.1, R701.2, U701.31 (~RESET); also elsewhere on the board
I2C5_SCL: U701.8 (SCL); also elsewhere on the board
I2C5_SDA: U701.9 (SDA); also elsewhere on the board
I2S_BCLK: U701.2 (BCLK); also elsewhere on the board
I2S_LRCK: U701.3 (WCLK); also elsewhere on the board
I2S_SDI: U701.5 (DOUT); also elsewhere on the board
I2S_SDO: U701.4 (DIN); also elsewhere on the board
MICBIAS: U701.15 (MICBIAS); also elsewhere on the board
MIC_EXT_L_AC: U701.10 (MIC1LP/LINE1LP); also elsewhere on the board
MIC_EXT_R_AC: U701.12 (MIC1RP/LINE1RP); also elsewhere on the board
MIC_ONBOARD_AC: U701.16 (MIC2R/LINE2R); also elsewhere on the board

Notes on the sheet:
B.0 开发候选；脚位已建立，制造/成本和首板验收尚未完成。

Parts:
J101: RADXA_ZERO_3W; Radxa40P_Zhouri_B; MPN 2.54-2*20; LCSC C2977589

Connections:
+5V: J101.2, J101.4; also elsewhere on the board
CODEC_RST: J101.33; also elsewhere on the board
DXL_DIR: J101.11; also elsewhere on the board
I2C5_SCL: J101.29; also elsewhere on the board
I2C5_SDA: J101.31; also elsewhere on the board
I2S_BCLK: J101.12; also elsewhere on the board
I2S_LRCK: J101.35; also elsewhere on the board
I2S_SDI: J101.38; also elsewhere on the board
I2S_SDO: J101.40; also elsewhere on the board
UART2_RX: J101.10; also elsewhere on the board
UART2_TX: J101.8; also elsewhere on the board

Notes on the sheet:
B.0 开发候选；脚位已建立，制造/成本和首板验收尚未完成。

Schematic: servo_ttl.kicad_sch, 自主HAT B.0 / servo_ttl

Parts:
C401, C402: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
D401: 5.1V; D_SOD-323; MPN BZT52C5V1S-7-F; LCSC C151348
J401, J402: SERVO_AMP2; AMP2007_3P_B; MPN CNJM A2007WV-3P; LCSC C5151076
R401: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
R402, R403: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
R404: 0R; R_0603_1608Metric; MPN 0603WAF0000T5E; LCSC C21189
U801: SN74LVC1G126DBVR; SOT-23-5; MPN SN74LVC1G126DBVR; LCSC C7834
U802: SN74LVC1G125DBVR; SOT-23-5; MPN SN74LVC1G125DBVR; LCSC C23654

Connections:
DXL_DATA: D401.1 (K), J401.3, J402.3, R404.2
DXL_DATA_INT: R403.1, R404.1, U801.4, U802.2
DXL_DIR: R401.1, U801.1, U802.1; also elsewhere on the board
UART2_RX: U802.4; also elsewhere on the board
UART2_TX: R402.1, U801.2; also elsewhere on the board

Notes on the sheet:
B.0 开发候选；脚位已建立，制造/成本和首板验收尚未完成。

Schematic: testpoints.kicad_sch, 自主HAT B.0 / testpoints

Parts:
TP801: VBATT_2S_IN; TestPoint_Pad_D1.0mm
TP802: +5V; TestPoint_Pad_D1.0mm
TP803: +3V3; TestPoint_Pad_D1.0mm

Connections:
+5V: TP802.1; also elsewhere on the board

Notes on the sheet:
B.0 开发候选；脚位已建立，制造/成本和首板验收尚未完成。

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
Board: 2 copper layers, 65.0 x 30.0 mm, 79 parts (1 on the bottom side), 41 nets.

Other parts of the board:
FID1, FID2, FID3: Fiducial_1mm_Mask2mm; Fiducial_1mm_Mask2mm_B
H1, H2: MountingHole_2.7mm_M2.5; MountingHole_2.7_M2.5_Head4.5
H3, H4: MountingHole_2.7mm_M2.5
J502: QWIIC_3V3; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical
R501, R502: 10k; R_0603_1608Metric

Their connections:
I2C5_SCL: J502.4, R502.2; also elsewhere on the board
I2C5_SDA: J502.3, R501.2; also elsewhere on the board
