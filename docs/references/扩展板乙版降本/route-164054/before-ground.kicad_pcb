# Repository parkourlrc/pcb-yilv1982--duck-robot-89dbc81d6d (continued)

## KiCad design docs/references/扩展板乙版降本/route-164054/before-ground.kicad_pcb (continued)

Parts:
C301: 10uF35V; C_1206_3216Metric; MPN C3216X7R1V106KT000E; LCSC C76666
C302, C305: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C303, C304: 22uF25V; C_1210_3225Metric; MPN GRM32ER71E226KE15L; LCSC C21397
D301: SMBJ12A; D_SMB; MPN SMBJ12A-E3/52; LCSC C1973121
L301: 6.8uH; L_Sunlord_SWPA6045S; MPN SWPA6045S6R8MT; LCSC C57254
Q301: AO3404A; SOT-23; MPN AO3404A; LCSC C30010
R301: 100R; R_0603_1608Metric; MPN 0603WAF1000T5E; LCSC C22775
U301: AP63205WU-7; TSOT-23-6; MPN AP63205WU-7; LCSC C2071056
U302: LM5050-1; TSOT-23-6; MPN LM5050MKX-1/NOPB; LCSC C473393

Connections:
+5V: Q301.3 (D), U302.6 (OUT); also elsewhere on the board
+5V_PRE_IDEAL: C303.1, C304.1, L301.2, Q301.2 (S), U301.1 (FB), U302.4 (IN)
BUCK_BST: C302.1, U301.6 (BST)
BUCK_SW: C302.2, L301.1, U301.5 (SW)
IDEAL_GATE: Q301.1 (G), U302.5 (GATE)
IDEAL_VS: C305.1, R301.2, U302.1 (VS)
POWER_GND: C301.2, C303.2, C304.2, C305.2, D301.1 (A1), U301.4 (GND), U302.2 (GND), U302.3 (OFF); also elsewhere on the board
VBATT_2S_IN: C301.1, D301.2 (A2), R301.1, U301.2 (EN), U301.3 (VIN); also elsewhere on the board

Notes on the sheet:
B.0 开发候选；脚位已建立，制造/成本和首板验收尚未完成。

Parts:
C401, C402: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
D401: 5.1V; D_SOD-323; MPN BZT52C5V1S-7-F; LCSC C151348
J401, J402: SERVO_AMP2; AMP2007_3P_B; MPN CNJMA2007WV-3P; LCSC C5151076
R401: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
R402, R403: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
R404: 0R; R_0603_1608Metric; MPN 0603WAF0000T5E; LCSC C21189
U801: SN74LVC1G126DBVR; SOT-23-5; MPN SN74LVC1G126DBVR; LCSC C7834
U802: SN74LVC1G125DBVR; SOT-23-5; MPN SN74LVC1G125DBVR; LCSC C23654

Connections:
DXL_DATA: D401.1 (K), J401.3, J402.3, R404.2
DXL_DATA_INT: R403.1, R404.1, U801.4, U802.2
DXL_DIR: R401.1, U801.1, U802.1; also elsewhere on the board
POWER_GND: C401.2, C402.2, D401.2 (A), J401.1, J402.1, R401.2, U801.3 (GND), U802.3 (GND); also elsewhere on the board
UART2_RX: U802.4; also elsewhere on the board
UART2_TX: R402.1, U801.2; also elsewhere on the board
VBATT_2S_IN: J401.2, J402.2; also elsewhere on the board

Notes on the sheet:
B.0 开发候选；脚位已建立，制造/成本和首板验收尚未完成。
