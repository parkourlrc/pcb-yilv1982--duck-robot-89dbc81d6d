# Repository parkourlrc/pcb-yilv1982--duck-robot-89dbc81d6d (continued)

## KiCad design docs/references/扩展板乙版降本/route-171730/custom_hat_rev_b.kicad_pcb (continued)

Parts:
C731, C732, C733, C738: 1uF; C_0603_1608Metric; MPN CL10A105KB8NNNC; LCSC C15849
C734, C736: 10uF; C_0603_1608Metric; MPN C1608X5R1A106KT000E; LCSC C76608
C735, C737: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C739, C740: 220pF; C_0603_1608Metric; MPN 0603CG221J500NT; LCSC C156398
FB701: 600R@100MHz; L_0603_1608Metric; MPN BLM18KG601SN1D; LCSC C85833
FB702, FB703: 120R@100MHz; L_0603_1608Metric; MPN PE-0603PFB121ST; LCSC C2661472
J506: SPEAKER; A1251_2P_B; MPN A1251WV-2P; LCSC C5333427
R731: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
U803: PAM8406DR; SOIC-16_3.9x9.9mm_P1.27mm; MPN PAM8406DR; LCSC C86270

Connections:
+5V: C734.1, C735.1, C736.1, C737.1, FB701.1, U803.4 (PVDDL), U803.13 (PVDDR); also elsewhere on the board
AMP_LEFT_INPUT: C731.2, U803.7 (INL)
AMP_RIGHT_INPUT: C732.2, U803.10 (INR)
AMP_R_N_RAW: FB702.1, U803.14 (-OUT_R)
AMP_R_P_RAW: FB703.1, U803.16 (+OUT_R)
AMP_VDD_FILT: C738.1, FB701.2, U803.6 (VDD)
AMP_VREF: C733.1, U803.8 (VREF)
AUDIO_AMP_EN: R731.2, U803.12 (~SHND)
CODEC_LEFT_LOP: C731.1; also elsewhere on the board
CODEC_RIGHT_LOP: C732.1; also elsewhere on the board
POWER_GND: C733.2, C734.2, C735.2, C736.2, C737.2, C738.2, C739.2, C740.2, U803.2 (PGNDL), U803.11 (GND), U803.15 (PGNDR); also elsewhere on the board
SPK_N: C739.1, FB702.2, J506.2
SPK_P: C740.1, FB703.2, J506.1

Notes on the sheet:
B.0 开发候选；脚位已建立，制造/成本和首板验收尚未完成。

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
Board: 2 copper layers, 65.0 x 30.0 mm, 76 parts (1 on the bottom side), 41 nets.

Other parts of the board:
H1, H2: MountingHole_2.7mm_M2.5; MountingHole_2.7_M2.5_Head4.5
H3, H4: MountingHole_2.7mm_M2.5
J101: RADXA_ZERO_3W; Radxa40P_Zhouri_B
J502: QWIIC_3V3; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical
R501, R502: 10k; R_0603_1608Metric
TP801: VBATT_2S_IN; TestPoint_Pad_D1.0mm
TP802: +5V; TestPoint_Pad_D1.0mm
TP803: +3V3; TestPoint_Pad_D1.0mm

Their connections:
+5V: J101.2, J101.4, TP802.1; also elsewhere on the board
CODEC_RST: J101.33; also elsewhere on the board
DXL_DIR: J101.11; also elsewhere on the board
I2C5_SCL: J101.29, J502.4, R502.2; also elsewhere on the board
I2C5_SDA: J101.31, J502.3, R501.2; also elsewhere on the board
I2S_BCLK: J101.12; also elsewhere on the board
I2S_LRCK: J101.35; also elsewhere on the board
I2S_SDI: J101.38; also elsewhere on the board
I2S_SDO: J101.40; also elsewhere on the board
POWER_GND: J101.6, J101.9, J101.14, J101.20, J101.25, J101.30, J101.34, J101.39, J502.1, J502.MP; also elsewhere on the board
UART2_RX: J101.10; also elsewhere on the board
UART2_TX: J101.8; also elsewhere on the board
VBATT_2S_IN: TP801.1; also elsewhere on the board
