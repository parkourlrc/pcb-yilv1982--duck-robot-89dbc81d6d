# Repository parkourlrc/pcb-yilv1982--duck-robot-89dbc81d6d (continued)

## KiCad design hardware/custom_hat/rev_a/custom_hat_rev_a.kicad_pcb (continued)

Parts:
C310, C312, C327: 100nF; C_0402_1005Metric
C311, C313, C315, C321, C322, C325, C326: 1uF; C_0402_1005Metric
C317, C318: 10uF; C_0402_1005Metric
C323: 10uF; C_0805_2012Metric
J504: AUDIO_OUT_SH; JST_SH_BM03B-SRSS-TB_1x03-1MP_P1.00mm_Vertical
J505: MIC_IN; JST_SH_BM02B-SRSS-TB_1x02-1MP_P1.00mm_Vertical
J506: SPEAKER; JST_SH_BM02B-SRSS-TB_1x02-1MP_P1.00mm_Vertical
R308: 10k; R_0402_1005Metric
R311: 100k; R_0402_1005Metric
R312: 2.2k; R_0402_1005Metric
U701: TLV320AIC3104; VQFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm
U803: PAM8302A; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+1V8_CODEC: C311.1, U701.32 (DVDD); also elsewhere on the board
+3V3: C312.1, C313.1, C315.1, R308.2, R311.2, U701.7 (IOVDD), U701.18 (DRVDD), U701.24 (DRVDD), U701.25 (AVDD); also elsewhere on the board
+5V: C323.1, U803.6 (VDD); also elsewhere on the board
AUDIO_AMP_EN: R311.1, U803.1 (~SD)
AUDIO_AMP_INN: C322.1, U803.4 (IN-)
AUDIO_AMP_INP: C321.2, U803.3 (IN+)
AUDIO_HP_L: C317.1, U701.19 (HPLOUT)
AUDIO_HP_R: C318.1, U701.23 (HPROUT)
AUDIO_L: C317.2, J504.1
AUDIO_LINE_L: C321.1, U701.27 (LEFT_LOP)
AUDIO_MIC: C325.1, J505.1, R312.2
AUDIO_MIC_AC: C325.2, U701.10 (MIC1LP/LINE1LP)
AUDIO_MIC_BIAS: C327.1, R312.1, U701.15 (MICBIAS)
AUDIO_MIC_REF: C326.2, U701.11 (MIC1LM/LINE1LM)
AUDIO_R: C318.2, J504.2
CODEC_RST: C310.1, R308.1, U701.31 (~RESET); also elsewhere on the board
I2C5_SCL: U701.8 (SCL); also elsewhere on the board
I2C5_SDA: U701.9 (SDA); also elsewhere on the board
I2S_BCLK: U701.2 (BCLK); also elsewhere on the board
I2S_LRCK: U701.3 (WCLK); also elsewhere on the board
I2S_MCLK: U701.1 (MCLK); also elsewhere on the board
I2S_SDI: U701.5 (DOUT); also elsewhere on the board
I2S_SDO: U701.4 (DIN); also elsewhere on the board
POWER_GND: C310.2, C311.2, C312.2, C313.2, C315.2, C322.2, C323.2, C326.1, C327.2, J504.3, J505.2, U701.6 (DVSS), U701.17 (AVSS1), U701.21 (DRVSS), U701.26 (AVSS2), U701.33 (EP), U803.7 (GND); also elsewhere on the board
SPK_N: J506.2, U803.8 (OUT-)
SPK_P: J506.1, U803.5 (OUT+)

Notes on the sheet:
Mic: electret biased from MICBIAS via R312 2.2k, AC-coupled by C325 into MIC1LP; MIC1LM is AC-coupled to GND by C326. Speaker: PAM8302A from LEFT_LOP through C321, /SD pulled up by R311, 2-pin speaker on J506.
TLV320AIC3104, pinout from the TI IBIS model. I2C 0x18. DVDD(32)=1.8V, IOVDD(7)=3.3V, AVDD(25)=3.3V, DRVDD(18/24)=3.3V. Unused analog inputs left open (see research note).
This page is a pin contract pending full C1 audio schematic re-implementation; no fabricated analog values are implied.

Board: 4 copper layers, 65.0 x 30.0 mm, 72 parts (38 on the bottom side), 42 nets.

Other parts of the board:
C328: 2.2uF; C_0805_2012Metric
C329, C330: 100nF; C_0402_1005Metric
FID1, FID2, FID3, FID4, FID5, FID6: Fiducial_1mm_Mask2mm
H1, H2: MountingHole_2.7mm_M2.5; MountingHole_2.7_M2.5_Head4.5
H3, H4: MountingHole_2.7mm_M2.5
J802: IMU_INT_TP; Samtec_TSW102_07
TP801: VBATT_2S_IN; TestPoint_Pad_D1.5mm
TP802: +5V; TestPoint_Pad_D1.5mm
TP803: +3V3; TestPoint_Pad_D1.5mm

Their connections:
+3V3: C329.1, C330.1, TP803.1; also elsewhere on the board
+5V: C328.1, TP802.1; also elsewhere on the board
BMI_INT1_TP: J802.1; also elsewhere on the board
BMI_INT3_TP: J802.2; also elsewhere on the board
POWER_GND: C328.2, C329.2, C330.2; also elsewhere on the board
VBATT_2S_IN: TP801.1; also elsewhere on the board

File hardware/custom_hat/rev_a/production-20261030-review/bom.csv:

"Refs","Value","Footprint","Qty","DNP"
"C301","3.3nF","Capacitor_SMD:C_0805_2012Metric","1",""
"C302","100nF","Capacitor_SMD:C_0805_2012Metric","1",""
"C303","10uF","Capacitor_SMD:C_1206_3216Metric","1",""
"C304","10uF","Capacitor_SMD:C_1206_3216Metric","1",""
"C305","22uF","Capacitor_SMD:C_1206_3216Metric","1",""
"C306","22uF","Capacitor_SMD:C_1206_3216Metric","1",""
"C308","1uF","Capacitor_SMD:C_0805_2012Metric","1",""
"C309","1uF","Capacitor_SMD:C_0805_2012Metric","1",""
"C310","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C311","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C312","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C313","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C315","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C317","10uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C318","10uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C319","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C320","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C321","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C322","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C323","10uF","Capacitor_SMD:C_0805_2012Metric","1",""
"C325","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C326","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C327","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"D301","SMBJ12A (fitted)","Diode_SMD:D_SMB","1",""
"FLG1","+5V","","1",""
"FLG2","+3V3","","1",""
"FLG3","VBATT_2S_IN","","1",""
"FLG4","POWER_GND","","1",""
"J101","RADXA_ZERO_3W_40P","Connector_PinSocket_2.54mm:PinSocket_2x20_P2.54mm_Vertical","1",""
"J301","POWER_AND_RAILS","Connector_PinHeader_2.54mm:PinHeader_1x08_P2.54mm_Vertical","1",""
"J401","DYNAMIXEL_TTL_1","Connector_JST:JST_EH_B3B-EH-A_1x03_P2.50mm_Vertical","1",""
"J402","DYNAMIXEL_TTL_2","Connector_JST:JST_EH_B3B-EH-A_1x03_P2.50mm_Vertical","1",""
"J403","HOST_UART2","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","1",""
"J502","TOF_I2C5","Connector_JST:JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical","1",""
"J504","AUDIO_OUT_SH","Connector_JST:JST_SH_BM03B-SRSS-TB_1x03-1MP_P1.00mm_Vertical","1",""
"J505","MIC_IN","Connector_JST:JST_SH_BM02B-SRSS-TB_1x02-1MP_P1.00mm_Vertical","1",""
"J506","SPEAKER","Connector_JST:JST_SH_BM02B-SRSS-TB_1x02-1MP_P1.00mm_Vertical","1",""
"J802","IMU_INT_TP","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1",""
"L301","5.5uH","Inductor_SMD:L_12x12mm_H8mm","1",""
"R301","52.3k","Resistor_SMD:R_0805_2012Metric","1",""
"R302","10k","Resistor_SMD:R_0805_2012Metric","1",""
"R303","200k","Resistor_SMD:R_0805_2012Metric","1",""
"R304","14k","Resistor_SMD:R_0805_2012Metric","1",""
"R305","100k","Resistor_SMD:R_0805_2012Metric","1",""
"R308","10k","Resistor_SMD:R_0402_1005Metric","1",""
"R309","0R","Resistor_SMD:R_1206_3216Metric","1",""
"R310","100k","Resistor_SMD:R_0402_1005Metric","1",""
"R311","100k","Resistor_SMD:R_0402_1005Metric","1",""
"R312","2.2k","Resistor_SMD:R_0402_1005Metric","1",""
"TP801","VBATT_2S_IN","TestPoint:TestPoint_Pad_D1.5mm","1",""
"TP802","+5V","TestPoint:TestPoint_Pad_D1.5mm","1",""
"TP803","+3V3","TestPoint:TestPoint_Pad_D1.5mm","1",""
"U301","AP64350","duck:SO-8EP_AP64350","1",""
"U501","BMI088","Package_LGA:Bosch_LGA-16_4.5x3mm_P0.5mm_LayoutBorder7x1y_ClockwisePinNumbering","1",""
"U701","TLV320AIC3104","Package_DFN_QFN:VQFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm","1",""
"U702","LP38693DT-1.8 codec 1V8","Package_TO_SOT_SMD:TO-252-3_TabPin2","1",""
"U801","SN74LVC1G126","Package_TO_SOT_SMD:SOT-23-5","1",""
"U802","SN74LVC1G125","Package_TO_SOT_SMD:SOT-23-5","1",""
"U803","PAM8302A","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","1",""

## KiCad design docs/references/扩展板乙版降本/route-171730/custom_hat_rev_b.kicad_pcb

File docs/README.md:

# docs 目录索引

本目录放本项目自己的方案、测试单、训练存档、图纸/照片索引和调研证据；上游只读资料在 [references](../references/README.md)，本机调研在 [docs/references](references/README.md)。

## 阅读顺序

[AGENTS](../AGENTS.md) → [项目概览](../README.md) → [PROGRESS](../PROGRESS.md) → [BOM](../BOM.md) → 本索引 → 任务专题。

## 子目录

| 目录 | 内容 |
|---|---|
| [references/](references/README.md) | 本机调研证据；按纯中文主题名，入口 README |
| [photos/](photos/README.md) | 用户硬件照片、标注图与索引 |
| [schematics/](schematics/README.md) | 原理图、设计源、网表及来源/版本 |
| [specs/](specs/README.md) | 任务 spec；每任务一个 `YYYYMMDD-主题/` |
| [video-notes/](video-notes/) | 视频笔记、时间戳与核验材料 |
| [archive/](archive/README.md) | 已移出入口的历史事件与过期指南 |

## 根级文档

- 流程与计划：[硬件模块研发流程](hardware-module-development-workflow.md)、[PCB 全流程运行手册](pcb-production-runbook.md)、[Spec 流程](spec-process.md)、[real2sim2real 工具链计划](real2sim2real-toolchain-plan.md)
- 供电：[v2 架构](power-architecture-v2.md)（讨论基线）、[v1](power-architecture-v1.md)（历史）、[过流保护](overcurrent-protection.md)
- 测试单：[HAT V1.2](hat-v1.2-test.md)（历史版）、[IMU 台架](imu-gd32-bench-test.md)（历史版）、[降压模块](buck-module-test.md)
- 训练：[A 线](a-training.md)、[B 线](b-training.md)、[A 线验收数据](a-training-validation.json)
- 工具/映射：[台架工具](bench-tools.md)、[舵机 ID 映射](servo-id-mapping.md)
- 回退：[A 线基线](route-a-baseline-20260928.md)、[A 线 BOM](bom-route-a-20260928.md)

## 边界

- 调研证据与原始照片只追加不覆盖；结论分级与来源写在专题 `research.md`。
- 历史测试单和旧路线文档保留，但不得直接作为当前接线/上电依据。

Notes on the sheet:
5片目标总价 <= 750元；两层/单面SMT；无板载BMI088；当前不是生产放行。
